require kodi.inc

SRCREV="02e7013889e08d608363f2909ebeccdb9ea3b7c9"
PV = "12.2+gitr${SRCPV}"
